# Keil uVision project lab4 ADC.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab4 ADC
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RA1
  c include: C:\Keil_v5\TivaWare_C_Series-2.1.4.178
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c startup_rvmdk.S
    C:/Keil_v5/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
  group Tivaware
    C:/Keil_v5/TivaWare_C_Series-2.1.4.178/driverlib/: adc.c interrupt.c cpu.c
